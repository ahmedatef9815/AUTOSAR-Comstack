# IAR project PduR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ComStack_Types.h Det.c Det.h helper.h main.c PduR.c PduR.h PduR_CanTp.c PduR_CanTp.h PduR_Cfg.h PduR_Com.c PduR_Com.h PduR_PBCfg.c PduR_PBCfg.h Platform_Types.h Std_Types.h
